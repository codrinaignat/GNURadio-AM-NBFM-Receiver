options:
  parameters:
    author: Codrina Lisaru
    generate_options: qt_gui
    id: AM_NBFM_Receiver_Codrina_Lisaru
    output_language: python
    title: 'Apl3: AM/NBFM Receiver_Codrina Lisaru'
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Display Bandwidth
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: 100e6
    value: '4800'
  states: {}
- name: Center_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center frequency in Hz
    orient: Qt.Horizontal
    start: 100e3
    step: step
    stop: 1760e6
    value: '126944900'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: RF Gain in dB
    orient: Qt.Vertical
    start: '0'
    step: '1'
    stop: '45'
    value: '40'
  states: {}
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Select receiver type
    label0: AM Receiver
    label1: NBFM Receiver
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,2
    label: Squelch [NBFM Use Only]
    orient: Qt.Horizontal
    start: '-110'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: step
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Center freq step size in Hz
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '200000'
    value: '100'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: 'Frequency Start for RTL-SDR blue stick is '
    type: string
    value: 24 MHz
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.5'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: chooser
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '10'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '7500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: Center_frequency
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    grid: 'True'
    gui_hint: 5,0,1,2
    legend: 'False'
    name: Spectrum Analyzer
    type: complex
    update_time: '0.001'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: Center_frequency
    fftsize: '1024'
    gui_hint: 6,0,1,2
    legend: 'False'
    name: Waterfall (Spectrogram)
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '12'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0, '1', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', blocks_selector_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
